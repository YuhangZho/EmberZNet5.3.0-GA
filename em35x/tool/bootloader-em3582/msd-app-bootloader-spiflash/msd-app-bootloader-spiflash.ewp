# IAR project msd-app-bootloader-spiflash.ewp, settings and files
configuration Normal (ARM, debug)
  General.RTConfigPath: $TOOLKIT_DIR$\INC\DLib_Config_Normal.h
  General.OGChipSelectEditMenu: default None
  ICCARM.CCDefines: BOARD_HEADER="hal/micro/cortexm3/em35x/board/dev0680etm.h"; PLATFORM_HEADER="hal/micro/cortexm3/compiler/iar-boot.h"; HAL_MICRO; CORTEXM3; CORTEXM3_EM3582; PHY_NULL; BOARD_DEV0680ETM; CORTEXM3_EMBER_MICRO; BTL_HAS_SERIAL; BOOTLOADER; SPI_FLASH_SC1; MSD_BOOTLOADER; EEPROM_USES_SHUTDOWN_CONTROL; BOOTLOADER_TYPE=BL_EXT_TYPE_APP_SPI; USB_MSD; __SOURCEFILE__="$FILE_FNAME$"
  ICCARM.CCDiagSuppress: Pa050
  ICCARM.CCIncludePath2: $FILE_DIR$\; ..\..\..\; ..\..\..\STACK\; ..\..\..\HAL\; ..\..\..\
  ICCARM.CCStdIncludePath: $TOOLKIT_DIR$\INC\
  ICCARM.CCOptLevel: 3
  ICCARM.CCOptStrategy: 1
  AARM.ADefines: BOARD_HEADER="hal/micro/cortexm3/em35x/board/dev0680etm.h"; PLATFORM_HEADER="hal/micro/cortexm3/compiler/iar-boot.h"; HAL_MICRO; CORTEXM3; CORTEXM3_EM3582; PHY_NULL; BOARD_DEV0680ETM; CORTEXM3_EMBER_MICRO; BTL_HAS_SERIAL; BOOTLOADER; SPI_FLASH_SC1; MSD_BOOTLOADER; EEPROM_USES_SHUTDOWN_CONTROL; BOOTLOADER_TYPE=BL_EXT_TYPE_APP_SPI; USB_MSD
  AARM.AUserIncludes: as above
  OBJCOPY.OOCOutputFile: msd-app-bootloader-spiflash.s37
  postbuild: "$_ISA3_UTILS_DIR_$\em3xx_convert.exe" "$TARGET_BPATH$.s37" "$TARGET_BPATH$.ebl"
  ILINK.IlinkOutputFile: msd-app-bootloader-spiflash.out
  ILINK.IlinkConfigDefines: BOOTLOADER=1
  ILINK.IlinkIcfFile: ../../../hal/micro/cortexm3/em35x/em3582/iar-cfg.icf
  ILINK.IlinkProgramEntryLabel: halEntryPoint
  group (top)
    ../../../hal/micro/cortexm3/bootloader/: app-bootloader-custom.c bootloader-gpio.c cstartup-iar-boot.c cstartup-iar-boot-entry.s79 spiflash-class1.c
    ../../../hal/micro/generic/: crc.c mem-util.c random.c
    ../../../hal/micro/cortexm3/usb/: em_usbd.c em_usbdch9.c em_usbdep.c em_usbhal.c em_usbint.c
    ../../../hal/micro/cortexm3/: isr-stubs.s79 led.c mfg-token.c micro-common.c
    ../../../build/msd-app-bootloader-library-cortexm3-iarboot-em3582-null/: msd-app-bootloader-library.a
    ../../../hal/micro/cortexm3/usb/msd/: msdd.c msddmedia.c
