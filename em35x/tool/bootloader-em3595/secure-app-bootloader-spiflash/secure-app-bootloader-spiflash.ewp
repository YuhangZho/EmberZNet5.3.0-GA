# IAR project secure-app-bootloader-spiflash.ewp, settings and files
configuration Normal (ARM, debug)
  General.RTConfigPath: $TOOLKIT_DIR$\INC\DLib_Config_Normal.h
  General.OGChipSelectEditMenu: default None
  ICCARM.CCDefines: EEPROM_USES_SHUTDOWN_CONTROL; SPI_FLASH_SC1; BOARD_HEADER="hal/micro/cortexm3/em35x/board/pcb0859.h"; PLATFORM_HEADER="hal/micro/cortexm3/compiler/iar-boot.h"; HAL_MICRO; CORTEXM3; CORTEXM3_EM3595; PHY_NULL; BOARD_PCB0859; CORTEXM3_EMBER_MICRO; BTL_HAS_SERIAL; BOOTLOADER; BOOTLOADER_TYPE=BL_EXT_TYPE_APP_SPI; __SOURCEFILE__="$FILE_FNAME$"
  ICCARM.CCDiagSuppress: Pa050
  ICCARM.CCIncludePath2: $FILE_DIR$\; ..\..\..\; ..\..\..\STACK\; ..\..\..\HAL\; ..\..\..\
  ICCARM.CCStdIncludePath: $TOOLKIT_DIR$\INC\
  ICCARM.CCOptLevel: 3
  ICCARM.CCOptStrategy: 1
  AARM.ADefines: EEPROM_USES_SHUTDOWN_CONTROL; SPI_FLASH_SC1; BOARD_HEADER="hal/micro/cortexm3/em35x/board/pcb0859.h"; PLATFORM_HEADER="hal/micro/cortexm3/compiler/iar-boot.h"; HAL_MICRO; CORTEXM3; CORTEXM3_EM3595; PHY_NULL; BOARD_PCB0859; CORTEXM3_EMBER_MICRO; BTL_HAS_SERIAL; BOOTLOADER; BOOTLOADER_TYPE=BL_EXT_TYPE_APP_SPI
  AARM.AUserIncludes: as above
  OBJCOPY.OOCOutputFile: secure-app-bootloader-spiflash.s37
  postbuild: "$_ISA3_UTILS_DIR_$\em3xx_convert.exe" "$TARGET_BPATH$.s37" "$TARGET_BPATH$.ebl"
  ILINK.IlinkOutputFile: secure-app-bootloader-spiflash.out
  ILINK.IlinkConfigDefines: BOOTLOADER=1
  ILINK.IlinkIcfFile: ../../../hal/micro/cortexm3/em35x/em3595/iar-cfg.icf
  ILINK.IlinkProgramEntryLabel: halEntryPoint
  group (top)
    ../../../hal/micro/cortexm3/bootloader/: app-bootloader-custom.c bootloader-gpio.c bootloader-uart.c cstartup-iar-boot.c cstartup-iar-boot-entry.s79 spiflash-class1.c
    ../../../hal/micro/generic/: crc.c mem-util.c random.c
    ../../../hal/micro/cortexm3/: isr-stubs.s79 led.c mfg-token.c micro-common.c
    ../../../build/secure-app-bootloader-library-cortexm3-iarboot-em3595-null/: secure-app-bootloader-library.a
