# IAR project sniff.ewp, settings and files
configuration Normal (ARM, debug)
  General.RTConfigPath: $TOOLKIT_DIR$\INC\DLib_Config_Normal.h
  General.OGChipSelectEditMenu: default None
  ICCARM.CCDefines: BOARD_HEADER="hal/micro/cortexm3/em35x/board/dev0680etm.h"; PLATFORM_HEADER="hal/micro/cortexm3/compiler/iar.h"; HAL_MICRO; CORTEXM3; CORTEXM3_EM3582; PHY_EM3XX; BOARD_DEV0680ETM; CORTEXM3_EMBER_MICRO; DEBUG; DEBUG_PACKET_TRACE; ENABLE_ALT_FUNCTION_TX_ACTIVE; ENABLE_ALT_FUNCTION_NTX_ACTIVE; EMBER_NO_STACK; EMBER_SERIAL0_DEBUG; EMBER_SERIAL0_MODE=EMBER_SERIAL_FIFO; EMBER_SERIAL0_TX_QUEUE_SIZE=64; EMBER_SERIAL0_RX_QUEUE_SIZE=64; EMBER_MULTI_NETWORK_STRIPPED; __SOURCEFILE__="$FILE_FNAME$"
  ICCARM.CCDiagSuppress: Pa050
  ICCARM.CCIncludePath2: $FILE_DIR$\; ..\..\..\; ..\..\..\STACK\; ..\..\..\HAL\; ..\..\..\
  ICCARM.CCStdIncludePath: $TOOLKIT_DIR$\INC\
  ICCARM.CCOptLevel: 3
  ICCARM.CCOptStrategy: 1
  AARM.ADefines: BOARD_HEADER="hal/micro/cortexm3/em35x/board/dev0680etm.h"; PLATFORM_HEADER="hal/micro/cortexm3/compiler/iar.h"; HAL_MICRO; CORTEXM3; CORTEXM3_EM3582; PHY_EM3XX; BOARD_DEV0680ETM; CORTEXM3_EMBER_MICRO; DEBUG; DEBUG_PACKET_TRACE; ENABLE_ALT_FUNCTION_TX_ACTIVE; ENABLE_ALT_FUNCTION_NTX_ACTIVE; EMBER_NO_STACK; EMBER_SERIAL0_DEBUG; EMBER_SERIAL0_MODE=EMBER_SERIAL_FIFO; EMBER_SERIAL0_TX_QUEUE_SIZE=64; EMBER_SERIAL0_RX_QUEUE_SIZE=64; EMBER_MULTI_NETWORK_STRIPPED
  AARM.AUserIncludes: as above
  OBJCOPY.OOCOutputFile: sniff.s37
  postbuild: "$_ISA3_UTILS_DIR_$\em3xx_convert.exe" "$TARGET_BPATH$.s37" "$TARGET_BPATH$.ebl"
  ILINK.IlinkOutputFile: sniff.out
  ILINK.IlinkIcfFile: ../../../hal/micro/cortexm3/em35x/em3582/iar-cfg.icf
  ILINK.IlinkProgramEntryLabel: halEntryPoint
  group (top)
    ../../../hal/micro/cortexm3/: adc.c bootloader-interface.c bootloader-interface-app.c bootloader-interface-standalone.c button.c buzzer.c cstartup-iar-common.c diagnostic.c ext-device.c faults.s79 isr-stubs.s79 led.c mfg-token.c micro.c micro-common.c mpu.c sleep.c spi-master.c token.c token-def.c uart.c
    ../../../stack/platform/micro/cortexm3/: aes.c debug-jtag.c
    ../../../phy/em250class/: analogue.c analogue-cell-bias.c analogue-filter.c analogue-lna.c analogue-mod-dac.c analogue-vco.c phy-common.c
    ../../../stack/framework/: byte-utilities.c debug.c eui64.c event-control.c packet-buffer.c packet-header.c
    ../../../hal/micro/cortexm3/usb/cdc/: callbacks.c
    ../../../stack/platform/micro/generic/: cal-pads.c
    ../../../phy/: child-table.c phy-util.c
    ../../../app/util/serial/: command-interpreter.c serial.c
    ../../../hal/micro/generic/: crc.c endian.c mem-util.c random.c sim-eeprom.c
    ../../../hal/micro/cortexm3/usb/: em_usbd.c em_usbdch9.c em_usbdep.c em_usbhal.c em_usbint.c
    ../../../hal/: ember-configuration.c
    ../../../stack/core/: ember-version.c
    ../../../build/hal-library-cortexm3-iar-em3582-em3xx/: hal-library.a
    ../../../phy/em3xx/: phy.c
    ../../../app/test/: sniff.c
