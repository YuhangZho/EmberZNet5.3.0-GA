# IAR project mfg-sample-app.ewp, settings and files
configuration Normal (ARM, debug)
  General.OGChipSelectEditMenu: default None
  General.RTConfigPath2: $TOOLKIT_DIR$\INC\c\DLib_Config_Normal.h
  General.CoreVariant: 38
  General.FPU2: 0
  ICCARM.CCDefines: BOARD_HEADER="hal/micro/cortexm3/em35x/board/dev0680.h"; PLATFORM_HEADER="hal/micro/cortexm3/compiler/iar.h"; HAL_MICRO; CORTEXM3; CORTEXM3_EM357; PHY_EM3XX; BOARD_DEV0680; CORTEXM3_EMBER_MICRO; CONFIGURATION_HEADER="app/mfglib/mfg-lib-sample-configuration.h"; EMBER_SERIAL1_MODE=EMBER_SERIAL_FIFO; EMBER_SERIAL1_TX_QUEUE_SIZE=128; EMBER_SERIAL1_RX_QUEUE_SIZE=64; EMBER_SERIAL0_DEBUG; __SOURCEFILE__="$FILE_FNAME$"
  ICCARM.CCDiagSuppress: Pa050
  ICCARM.CCIncludePath2: $FILE_DIR$\; ..\..\..\; ..\..\..\STACK\; ..\..\..\HAL\; ..\..\..\
  ICCARM.CCOptLevel: 3
  ICCARM.CCOptStrategy: 1
  ICCARM.IccLang: 0
  AARM.ADefines: BOARD_HEADER="hal/micro/cortexm3/em35x/board/dev0680.h"; PLATFORM_HEADER="hal/micro/cortexm3/compiler/iar.h"; HAL_MICRO; CORTEXM3; CORTEXM3_EM357; PHY_EM3XX; BOARD_DEV0680; CORTEXM3_EMBER_MICRO; CONFIGURATION_HEADER="app/mfglib/mfg-lib-sample-configuration.h"; EMBER_SERIAL1_MODE=EMBER_SERIAL_FIFO; EMBER_SERIAL1_TX_QUEUE_SIZE=128; EMBER_SERIAL1_RX_QUEUE_SIZE=64; EMBER_SERIAL0_DEBUG
  AARM.AUserIncludes: as above
  OBJCOPY.OOCOutputFile: mfg-sample-app.s37
  postbuild: "$_ISA3_UTILS_DIR_$\em3xx_convert.exe" "$TARGET_BPATH$.s37" "$TARGET_BPATH$.ebl"
  ILINK.IlinkOutputFile: mfg-sample-app.out
  ILINK.IlinkIcfFile: ../../../hal/micro/cortexm3/em35x/em357/iar-cfg.icf
  ILINK.IlinkProgramEntryLabel: halEntryPoint
  group (top)
    ../../../hal/micro/cortexm3/: adc.c bootloader-interface-app.c bootloader-interface-standalone.c bootloader-interface.c button.c buzzer.c cstartup-iar-common.c diagnostic.c ext-device.c faults.s79 isr-stubs.s79 led.c mfg-token.c micro-common.c micro.c mpu.c sleep.c spi-master.c token-def.c token.c uart.c
    ../../alarm-library-cortexm3-iar-em357-em3xx/: alarm-library.a
    ../../binding-table-stub-library-cortexm3-iar-em357-em3xx/: binding-table-stub-library.a
    ../../cbke-163k1-stub-library-cortexm3-iar-em357-em3xx/: cbke-163k1-stub-library.a
    ../../cbke-283k1-stub-library-cortexm3-iar-em357-em3xx/: cbke-283k1-stub-library.a
    ../../cbke-library-dsa-sign-stub-cortexm3-iar-em357-em3xx/: cbke-library-dsa-sign-stub.a
    ../../cbke-library-dsa-verify-stub-cortexm3-iar-em357-em3xx/: cbke-library-dsa-verify-stub.a
    ../../cbke-stub-library-cortexm3-iar-em357-em3xx/: cbke-stub-library.a
    ../../../app/util/serial/: cli.c serial.c
    ../../../hal/micro/generic/: crc.c endian.c mem-util.c random.c sim-eeprom.c
    ../../../hal/: ember-configuration.c
    ../../end-device-bind-stub-library-cortexm3-iar-em357-em3xx/: end-device-bind-stub-library.a
    ../../hal-library-cortexm3-iar-em357-em3xx/: hal-library.a
    ../../install-code-library-stub-cortexm3-iar-em357-em3xx/: install-code-library-stub.a
    ../../../app/mfglib/: mfg-AdcControl.c mfg-AdcControl.h mfg-Flash.c mfg-Flash.h mfg-lib-sample-configuration.h mfg-MacRW.c mfg-MacRW.h mfg-PwmControl.c mfg-PwmControl.h mfg-sample.c
    ../../mfglib-library-cortexm3-iar-em357-em3xx/: mfglib-library.a
    ../../multi-network-stub-library-cortexm3-iar-em357-em3xx/: multi-network-stub-library.a
    ../../packet-validate-library-cortexm3-iar-em357-em3xx/: packet-validate-library.a
    ../../rf4ce-stack-stub-library-cortexm3-iar-em357-em3xx/: rf4ce-stack-stub-library.a
    ../../security-library-core-cortexm3-iar-em357-em3xx/: security-library-core.a
    ../../security-library-link-keys-stub-cortexm3-iar-em357-em3xx/: security-library-link-keys-stub.a
    ../../../hal/micro/cortexm3/bootloader/: spiflash-class1.c
    ../../zigbee-pro-stack-cortexm3-iar-em357-em3xx/: zigbee-pro-stack.a
    ../../zll-stub-library-cortexm3-iar-em357-em3xx/: zll-stub-library.a
