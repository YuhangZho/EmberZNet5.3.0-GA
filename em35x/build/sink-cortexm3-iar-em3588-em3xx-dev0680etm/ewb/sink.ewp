# IAR project sink.ewp, settings and files
configuration Normal (ARM, debug)
  General.RTConfigPath: $TOOLKIT_DIR$\INC\DLib_Config_Normal.h
  General.OGChipSelectEditMenu: default None
  ICCARM.CCDefines: BOARD_HEADER="hal/micro/cortexm3/em35x/board/dev0680etm.h"; PLATFORM_HEADER="hal/micro/cortexm3/compiler/iar.h"; HAL_MICRO; CORTEXM3; CORTEXM3_EM3588; PHY_EM3XX; BOARD_DEV0680ETM; CORTEXM3_EMBER_MICRO; CONFIGURATION_HEADER="app/sensor/sensor-configuration.h"; SINK_APP; EMBER_SERIAL1_MODE=EMBER_SERIAL_FIFO; EMBER_SERIAL1_TX_QUEUE_SIZE=128; EMBER_SERIAL1_RX_QUEUE_SIZE=16; EMBER_SERIAL0_DEBUG; EMBER_SERIAL0_MODE=EMBER_SERIAL_FIFO; EMBER_SERIAL0_TX_QUEUE_SIZE=128; EMBER_SERIAL0_RX_QUEUE_SIZE=64; SCAN_DEBUG_PRINT_ENABLE; USE_BOOTLOADER_LIB; __SOURCEFILE__="$FILE_FNAME$"
  ICCARM.CCDiagSuppress: Pa050
  ICCARM.CCIncludePath2: $FILE_DIR$\; ..\..\..\; ..\..\..\STACK\; ..\..\..\HAL\; ..\..\..\
  ICCARM.CCStdIncludePath: $TOOLKIT_DIR$\INC\
  ICCARM.CCOptLevel: 3
  ICCARM.CCOptStrategy: 1
  AARM.ADefines: BOARD_HEADER="hal/micro/cortexm3/em35x/board/dev0680etm.h"; PLATFORM_HEADER="hal/micro/cortexm3/compiler/iar.h"; HAL_MICRO; CORTEXM3; CORTEXM3_EM3588; PHY_EM3XX; BOARD_DEV0680ETM; CORTEXM3_EMBER_MICRO; CONFIGURATION_HEADER="app/sensor/sensor-configuration.h"; SINK_APP; EMBER_SERIAL1_MODE=EMBER_SERIAL_FIFO; EMBER_SERIAL1_TX_QUEUE_SIZE=128; EMBER_SERIAL1_RX_QUEUE_SIZE=16; EMBER_SERIAL0_DEBUG; EMBER_SERIAL0_MODE=EMBER_SERIAL_FIFO; EMBER_SERIAL0_TX_QUEUE_SIZE=128; EMBER_SERIAL0_RX_QUEUE_SIZE=64; SCAN_DEBUG_PRINT_ENABLE; USE_BOOTLOADER_LIB
  AARM.AUserIncludes: as above
  OBJCOPY.OOCOutputFile: sink.s37
  postbuild: "$_ISA3_UTILS_DIR_$\em3xx_convert.exe" "$TARGET_BPATH$.s37" "$TARGET_BPATH$.ebl"
  ILINK.IlinkOutputFile: sink.out
  ILINK.IlinkIcfFile: ../../../hal/micro/cortexm3/em35x/em3588/iar-cfg.icf
  ILINK.IlinkProgramEntryLabel: halEntryPoint
  group (top)
    ../../../hal/micro/cortexm3/: adc.c bootloader-interface.c bootloader-interface-app.c bootloader-interface-standalone.c button.c buzzer.c cstartup-iar-common.c diagnostic.c ext-device.c faults.s79 isr-stubs.s79 led.c mfg-token.c micro.c micro-common.c mpu.c sleep.c spi-master.c token.c token-def.c uart.c
    ../../../build/alarm-library-cortexm3-iar-em3588-em3xx/: alarm-library.a
    ../../../build/binding-table-library-cortexm3-iar-em3588-em3xx/: binding-table-library.a
    ../../../app/util/bootload/: bootload-utils.c
    ../../../hal/micro/cortexm3/usb/cdc/: callbacks.c
    ../../../build/cbke-163k1-stub-library-cortexm3-iar-em3588-em3xx/: cbke-163k1-stub-library.a
    ../../../build/cbke-283k1-stub-library-cortexm3-iar-em3588-em3xx/: cbke-283k1-stub-library.a
    ../../../build/cbke-library-dsa-sign-stub-cortexm3-iar-em3588-em3xx/: cbke-library-dsa-sign-stub.a
    ../../../build/cbke-library-dsa-verify-stub-cortexm3-iar-em3588-em3xx/: cbke-library-dsa-verify-stub.a
    ../../../build/cbke-stub-library-cortexm3-iar-em3588-em3xx/: cbke-stub-library.a
    ../../../app/sensor/: common.c sink.c
    ../../../hal/micro/generic/: crc.c endian.c mem-util.c random.c sim-eeprom.c
    ../../../hal/micro/cortexm3/usb/: em_usbd.c em_usbdch9.c em_usbdep.c em_usbhal.c em_usbint.c
    ../../../hal/: ember-configuration.c
    ../../../build/end-device-bind-stub-library-cortexm3-iar-em3588-em3xx/: end-device-bind-stub-library.a
    ../../../app/util/common/: form-and-join.c form-and-join-node-adapter.c form-and-join-node-callbacks.c
    ../../../build/hal-library-cortexm3-iar-em3588-em3xx/: hal-library.a
    ../../../build/install-code-library-stub-cortexm3-iar-em3588-em3xx/: install-code-library-stub.a
    ../../../build/multi-network-stub-library-cortexm3-iar-em3588-em3xx/: multi-network-stub-library.a
    ../../../build/packet-validate-library-cortexm3-iar-em3588-em3xx/: packet-validate-library.a
    ../../../build/rf4ce-stack-stub-library-cortexm3-iar-em3588-em3xx/: rf4ce-stack-stub-library.a
    ../../../app/util/security/: security-address-cache.c security-common.c trust-center.c
    ../../../build/security-library-core-cortexm3-iar-em3588-em3xx/: security-library-core.a
    ../../../build/security-library-link-keys-stub-cortexm3-iar-em3588-em3xx/: security-library-link-keys-stub.a
    ../../../app/util/serial/: serial.c
    ../../../app/util/: source-route.c source-route-common.c
    ../../../build/zigbee-pro-stack-cortexm3-iar-em3588-em3xx/: zigbee-pro-stack.a
    ../../../build/zll-stub-library-cortexm3-iar-em3588-em3xx/: zll-stub-library.a
