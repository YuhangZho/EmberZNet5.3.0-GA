# IAR project nodetest-usb.ewp, settings and files
configuration Normal (ARM, debug)
  General.RTConfigPath: $TOOLKIT_DIR$\INC\DLib_Config_Normal.h
  General.OGChipSelectEditMenu: default None
  ICCARM.CCDefines: BOARD_HEADER="hal/micro/cortexm3/em35x/board/dev0680nodetest.h"; PLATFORM_HEADER="hal/micro/cortexm3/compiler/iar.h"; HAL_MICRO; CORTEXM3; CORTEXM3_EM3588; PHY_EM3XX; BOARD_DEV0680NODETEST; CORTEXM3_EMBER_MICRO; MODULE_LIST="hal/test/nodetest-modules-em358_usb.ham"; CONFIGURATION_HEADER="hal/test/platformtest-configuration.h"; PLATFORMTEST; EMBER_NO_STACK; EMBER_SERIAL0_MODE=EMBER_SERIAL_FIFO; EMBER_SERIAL0_TX_QUEUE_SIZE=128; EMBER_SERIAL0_RX_QUEUE_SIZE=64; EMBER_SERIAL0_BLOCKING; EMBER_SERIAL1_MODE=EMBER_SERIAL_FIFO; EMBER_SERIAL1_TX_QUEUE_SIZE=128; EMBER_SERIAL1_RX_QUEUE_SIZE=64; EMBER_SERIAL1_BLOCKING; EMBER_SERIAL2_MODE=EMBER_SERIAL_FIFO; EMBER_SERIAL2_TX_QUEUE_SIZE=128; EMBER_SERIAL2_RX_QUEUE_SIZE=64; EMBER_SERIAL2_BLOCKING; EMBER_SERIAL3_MODE=EMBER_SERIAL_FIFO; EMBER_SERIAL3_TX_QUEUE_SIZE=128; EMBER_SERIAL3_RX_QUEUE_SIZE=64; EMBER_SERIAL3_BLOCKING; ONLY_PUBLIC_COMMANDS; NO_PRIVATE_COMMANDS; NODETEST; NODETEST_USB; SER232_AUTO; __SOURCEFILE__="$FILE_FNAME$"
  ICCARM.CCDiagSuppress: Pa050
  ICCARM.CCIncludePath2: $FILE_DIR$\; ..\..\..\; ..\..\..\STACK\; ..\..\..\HAL\; ..\..\..\
  ICCARM.CCStdIncludePath: $TOOLKIT_DIR$\INC\
  ICCARM.CCOptLevel: 3
  ICCARM.CCOptStrategy: 1
  AARM.ADefines: BOARD_HEADER="hal/micro/cortexm3/em35x/board/dev0680nodetest.h"; PLATFORM_HEADER="hal/micro/cortexm3/compiler/iar.h"; HAL_MICRO; CORTEXM3; CORTEXM3_EM3588; PHY_EM3XX; BOARD_DEV0680NODETEST; CORTEXM3_EMBER_MICRO; MODULE_LIST="hal/test/nodetest-modules-em358_usb.ham"; CONFIGURATION_HEADER="hal/test/platformtest-configuration.h"; PLATFORMTEST; EMBER_NO_STACK; EMBER_SERIAL0_MODE=EMBER_SERIAL_FIFO; EMBER_SERIAL0_TX_QUEUE_SIZE=128; EMBER_SERIAL0_RX_QUEUE_SIZE=64; EMBER_SERIAL0_BLOCKING; EMBER_SERIAL1_MODE=EMBER_SERIAL_FIFO; EMBER_SERIAL1_TX_QUEUE_SIZE=128; EMBER_SERIAL1_RX_QUEUE_SIZE=64; EMBER_SERIAL1_BLOCKING; EMBER_SERIAL2_MODE=EMBER_SERIAL_FIFO; EMBER_SERIAL2_TX_QUEUE_SIZE=128; EMBER_SERIAL2_RX_QUEUE_SIZE=64; EMBER_SERIAL2_BLOCKING; EMBER_SERIAL3_MODE=EMBER_SERIAL_FIFO; EMBER_SERIAL3_TX_QUEUE_SIZE=128; EMBER_SERIAL3_RX_QUEUE_SIZE=64; EMBER_SERIAL3_BLOCKING; ONLY_PUBLIC_COMMANDS; NO_PRIVATE_COMMANDS; NODETEST; NODETEST_USB; SER232_AUTO
  AARM.AUserIncludes: as above
  OBJCOPY.OOCOutputFile: nodetest-usb.s37
  postbuild: "$_ISA3_UTILS_DIR_$\em3xx_convert.exe" "$TARGET_BPATH$.s37" "$TARGET_BPATH$.ebl"
  ILINK.IlinkOutputFile: nodetest-usb.out
  ILINK.IlinkIcfFile: ../../../hal/micro/cortexm3/em35x/em3588/iar-cfg.icf
  ILINK.IlinkProgramEntryLabel: halEntryPoint
  group (top)
    ../../../hal/micro/cortexm3/: adc.c bootloader-interface.c bootloader-interface-app.c bootloader-interface-standalone.c button.c buzzer.c cstartup-iar-common.c diagnostic.c ext-device.c faults.s79 isr-stubs.s79 led.c mfg-token.c micro.c micro-common.c mpu.c sleep.c spi-master.c token.c token-def.c uart.c
    ../../../hal/micro/cortexm3/test/: adccal-test.c board-test.c button-test.c crash-info.c extflash-test.c gpio-test.c gpt-test.c led-test.c sleep-test.c token-cortexm3-test.c
    ../../../phy/bridge/test/: bridge-test.c
    ../../../hal/micro/cortexm3/usb/cdc/: callbacks.c
    ../../../stack/platform/micro/generic/: cal-pads.c
    ../../../phy/: child-table.c
    ../../../app/util/serial/: command-interpreter.c serial.c
    ../../../hal/micro/generic/: crc.c endian.c mem-util.c random.c sim-eeprom.c
    ../../../stack/framework/: debug.c event-control.c packet-buffer.c packet-header.c
    ../../../hal/micro/cortexm3/usb/: em_usbd.c em_usbdch9.c em_usbdep.c em_usbhal.c em_usbint.c
    ../../../hal/: ember-configuration.c
    ../../../stack/core/: ember-multi-network-stub.c ember-version.c
    ../../../build/hal-library-cortexm3-iar-em3588-em3xx/: hal-library.a
    ../../../stack/mac/802.15.4/: mac-header-stub.c scan-stub.c
    ../../../hal/test/: misc-test.c platformtest.c reset-test.c response.c token-test.c
    ../../../phy/test/: phy-common-rx-test.c phy-common-test.c phy-common-tx-test.c
    ../../../phy/em250class/test/: phy-em250class-test.c phy-em250class-timer-test-stub.c
    ../../../phy/em3xx/test/: phy-em3xx-test.c
    ../../../phy/bridge/ethernet/homeplug/green-phy/atheros/test/: pl04-test.c
    ../../../build/znetphy-library-cortexm3-iar-em3588-em3xx/: znetphy-library.a
