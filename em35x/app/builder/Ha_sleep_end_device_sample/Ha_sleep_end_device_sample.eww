<?xml version="1.0" encoding="iso-8859-1"?>
<!-- THIS IS A GENERATED FILE: PLEASE DO NOT EDIT -->

<workspace>
  <project>
    <path>$WS_DIR$\Ha_sleep_end_device_sample.ewp</path>
  </project>
  <batchBuild/>
</workspace>
