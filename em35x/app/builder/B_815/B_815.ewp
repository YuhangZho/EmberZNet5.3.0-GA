# IAR project B_815.ewp, settings and files
configuration Normal (ARM, debug)
  General.RTConfigPath: $TOOLKIT_DIR$\INC\DLib_Config_Normal.h
  General.OGChipSelectEditMenu: default None
  ICCARM.CCDefines: DEBUG; GENERATED_TOKEN_HEADER="app/builder/B_815/B_815_tokens.h"; ZA_GENERATED_HEADER="app/builder/B_815/B_815.h"; APP_BTL; BOARD_HEADER="app\builder\B_815\B_815_board.h"; PLATFORM_HEADER="hal/micro/cortexm3/compiler/iar.h"; CORTEXM3; CORTEXM3_EMBER_MICRO; CORTEXM3_EM357; PHY_EM3XX; APPLICATION_TOKEN_HEADER="app/framework/util/tokens.h"; CONFIGURATION_HEADER="app/framework/util/config.h"; RECEIVE_BROADCAST_NOT_REPORT=1; SENGLED_Z01_A19_UART=1; ATTRIBUTE_STORAGE_CONFIGURATION="app/builder/B_815/B_815_endpoint_config.h"; __SOURCEFILE__="$FILE_FNAME$"
  ICCARM.CCDiagSuppress: Pa050
  ICCARM.CCIncludePath2: $FILE_DIR$\; ; ..\..\..\; ..\..\..\app\framework\include; ..\..\..\; ..\..\..\stack\; ..\..\..\hal\; ..\..\..\hal\..\
  ICCARM.CCStdIncludePath: $TOOLKIT_DIR$\INC\
  ICCARM.CCOptLevel: 3
  ICCARM.CCOptStrategy: 1
  AARM.ADefines: DEBUG; GENERATED_TOKEN_HEADER="app/builder/B_815/B_815_tokens.h"; ZA_GENERATED_HEADER="app/builder/B_815/B_815.h"; APP_BTL; BOARD_HEADER="app\builder\B_815\B_815_board.h"; PLATFORM_HEADER="hal/micro/cortexm3/compiler/iar.h"; CORTEXM3; CORTEXM3_EMBER_MICRO; CORTEXM3_EM357; PHY_EM3XX; APPLICATION_TOKEN_HEADER="app/framework/util/tokens.h"; CONFIGURATION_HEADER="app/framework/util/config.h"; RECEIVE_BROADCAST_NOT_REPORT=1; SENGLED_Z01_A19_UART=1; ATTRIBUTE_STORAGE_CONFIGURATION="app/builder/B_815/B_815_endpoint_config.h"
  AARM.AUserIncludes: $FILE_DIR$\; ; ..\..\..\; ..\..\..\; ..\..\..\stack\; ..\..\..\hal\; ..\..\..\hal\..\
  OBJCOPY.OOCOutputFile: B_815.s37
  postbuild: B_815.bat $PROJ_DIR$ $TARGET_BPATH$
  ILINK.IlinkOutputFile: B_815.out
  ILINK.IlinkConfigDefines: APP_BTL=1
  ILINK.IlinkIcfFile: ../../../hal/micro/cortexm3/em35x/em357/iar-cfg.icf
  ILINK.IlinkProgramEntryLabel: halEntryPoint
  group (top)
    ../../../app/builder/B_815/: B_815_callbacks.c
    ../../../hal/micro/cortexm3/: bootloader-interface.c bootloader-interface-app.c adc.c button.c buzzer.c cstartup-iar-common.c diagnostic.c faults.s79 isr-stubs.s79 led.c mfg-token.c micro-common.c micro.c mpu.c sleep.c token-def.c token.c uart.c
    ../../../app/framework/plugin/address-table/: address-table-management.c address-table-cli.c address-table-soc.c
    ../../../app/framework/plugin/basic/: basic.c
    ../../../app/framework/plugin/color-control/: color-control.c
    ../../../app/framework/plugin/counters/: counters-cli.c counters-ota.c counters-soc.c
    ../../../app/framework/plugin/diagnostic-server/: diagnostic-server-soc.c
    ../../../app/framework/plugin/eeprom/: eeprom.c eeprom-cli.c
    ../../../app/framework/plugin/end-device-support/: end-device-support.c end-device-move.c end-device-support-cli.c polling-common.c polling-soc.c
    ../../../app/framework/plugin/ezmode-commissioning/: ez-mode.c
    ../../../app/framework/plugin/groups-server/: groups-server.c groups-server-cli.c
    ../../../app/framework/plugin/identify/: identify.c identify-cli.c
    ../../../app/framework/plugin/idle-sleep/: idle-sleep.c idle-sleep-cli.c idle-sleep-soc.c
    ../../../app/framework/plugin/level-control/: level-control.c
    ../../../app/framework/plugin/network-find/: network-find.c
    ../../../app/framework/plugin/on-off/: on-off.c
    ../../../app/framework/plugin/ota-bootload/: ota-bootload-cli.c ota-bootload-soc.c
    ../../../app/framework/plugin/ota-client/: ota-client.c ota-client-signature-verify.c ota-client-page-request.c ota-client-cli.c
    ../../../app/framework/plugin/ota-client-policy/: ota-client-policy.c
    ../../../app/framework/plugin/ota-common/: ota-common.c
    ../../../app/framework/plugin/ota-storage-common/: ota-storage-common.c ota-storage-common-cli.c
    ../../../app/framework/plugin/ota-storage-simple/: ota-storage-simple.c ota-storage-simple-simulation.c
    ../../../app/framework/plugin/ota-storage-simple-eeprom/: ota-storage-eeprom.c ota-storage-eeprom-page-erase.c ota-storage-eeprom-read-modify-write.c
    ../../../app/framework/plugin/reporting/: reporting.c reporting-cli.c
    ../../../app/framework/plugin/scenes/: scenes.c scenes-cli.c
    ../../../app/framework/plugin/sengled-ha-cli/: sengled-cli.c
    ../../../app/framework/plugin/sengled-ha-ezmode/: sengled-ha-ezmode.c
    ../../../app/framework/plugin/sengled-ha-network-B815/: sengled-network.c
    ../../../app/framework/plugin/sengled-hardware-B815/: sengled-hardware-TrackLight.c sengled-ledControl.c
    ../../../app/framework/plugin/simple-metering-server/: simple-metering-server.c simple-metering-test.c simple-metering-server-cli.c
    ./: call-command-handler.c callback-stub.c stack-handler-stub.c cli.c
    ../../../app/framework/util/: af-event.c af-main-common.c af-main-soc.c attribute-size.c attribute-storage.c attribute-table.c client-api.c print.c print-formatter.c process-cluster-message.c process-global-message.c service-discovery-common.c service-discovery-soc.c message.c multi-network.c util.c
    ../../../app/framework/security/: af-node.c af-security-common.c af-trust-center.c crypto-state.c
    ../../../app/util/serial/: command-interpreter2.c serial.c
    ../../../hal/micro/generic/: crc.c endian.c mem-util.c random.c sim-eeprom.c
    ../../../hal/: ember-configuration.c
    ../../../app/util/common/: form-and-join-node-adapter.c form-and-join.c library.c
    ../../../build/hal-library-cortexm3-iar-em357-em3xx/: hal-library.a
    ../../../app/framework/cli/: core-cli.c network-cli.c option-cli.c plugin-cli.c security-cli.c zcl-cli.c zdo-cli.c
    ../../../app/util/security/: security-address-cache.c
    ../../../hal/micro/cortexm3/usb/: em_usbd.c em_usbdch9.c em_usbdep.c em_usbhal.c em_usbint.c
    ../../../hal/micro/cortexm3/usb/cdc/: callbacks.c
    ../../../app/util/zigbee-framework/: zigbee-device-common.c zigbee-device-library.c
  group Libraries
    ../../../build/alarm-stub-library-cortexm3-iar-em357-em3xx/: alarm-stub-library.a
    ../../../build/binding-table-library-cortexm3-iar-em357-em3xx/: binding-table-library.a
    ../../../build/cbke-library-dsa-sign-stub-cortexm3-iar-em357-em3xx/: cbke-library-dsa-sign-stub.a
    ../../../build/cbke-library-dsa-verify-stub-cortexm3-iar-em357-em3xx/: cbke-library-dsa-verify-stub.a
    ../../../build/cbke-stub-library-cortexm3-iar-em357-em3xx/: cbke-stub-library.a
    ../../../build/cbke-163k1-stub-library-cortexm3-iar-em357-em3xx/: cbke-163k1-stub-library.a
    ../../../build/cbke-283k1-stub-library-cortexm3-iar-em357-em3xx/: cbke-283k1-stub-library.a
    ../../../build/end-device-bind-stub-library-cortexm3-iar-em357-em3xx/: end-device-bind-stub-library.a
    ../../../build/install-code-library-stub-cortexm3-iar-em357-em3xx/: install-code-library-stub.a
    ../../../build/multi-network-stub-library-cortexm3-iar-em357-em3xx/: multi-network-stub-library.a
    ../../../build/packet-validate-library-cortexm3-iar-em357-em3xx-debug/: packet-validate-library.a
    ../../../build/rf4ce-stack-stub-library-cortexm3-iar-em357-em3xx/: rf4ce-stack-stub-library.a
    ../../../build/security-library-link-keys-cortexm3-iar-em357-em3xx/: security-library-link-keys.a
    ../../../build/security-library-core-cortexm3-iar-em357-em3xx/: security-library-core.a
    ../../../build/zigbee-pro-leaf-stack-cortexm3-iar-em357-em3xx-debug/: zigbee-pro-leaf-stack.a
    ../../../build/zll-stub-library-cortexm3-iar-em357-em3xx/: zll-stub-library.a
