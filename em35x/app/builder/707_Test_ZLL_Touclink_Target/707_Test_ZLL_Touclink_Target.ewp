# IAR project 707_Test_ZLL_Touclink_Target.ewp, settings and files
configuration Normal (ARM, debug)
  General.OGChipSelectEditMenu: default None
  General.RTConfigPath2: $TOOLKIT_DIR$\INC\c\DLib_Config_Normal.h
  General.CoreVariant: 38
  General.FPU2: 0
  ICCARM.CCDefines: DEBUG; GENERATED_TOKEN_HEADER="app/builder/707_Test_ZLL_Touclink_Target/707_Test_ZLL_Touclink_Target_tokens.h"; ZA_GENERATED_HEADER="app/builder/707_Test_ZLL_Touclink_Target/707_Test_ZLL_Touclink_Target.h"; NULL_BTL; BOARD_HEADER="app\builder\707_Test_ZLL_Touclink_Target\707_Test_ZLL_Touclink_Target_board.h"; PLATFORM_HEADER="hal/micro/cortexm3/compiler/iar.h"; CORTEXM3; CORTEXM3_EMBER_MICRO; CORTEXM3_EM357; PHY_EM3XX; APPLICATION_TOKEN_HEADER="app/framework/util/tokens.h"; CONFIGURATION_HEADER="app/framework/util/config.h"; SENGLED_COR=1; ATTRIBUTE_STORAGE_CONFIGURATION="app/builder/707_Test_ZLL_Touclink_Target/707_Test_ZLL_Touclink_Target_endpoint_config.h"; __SOURCEFILE__="$FILE_FNAME$"
  ICCARM.CCDiagSuppress: Pa050
  ICCARM.CCIncludePath2: $FILE_DIR$\; ; ..\..\..\; ..\..\..\app\framework\include; ..\..\..\; ..\..\..\stack\; ..\..\..\hal\; ..\..\..\hal\..\
  ICCARM.CCOptLevel: 3
  ICCARM.CCOptStrategy: 1
  ICCARM.IccLang: 0
  AARM.ADefines: DEBUG; GENERATED_TOKEN_HEADER="app/builder/707_Test_ZLL_Touclink_Target/707_Test_ZLL_Touclink_Target_tokens.h"; ZA_GENERATED_HEADER="app/builder/707_Test_ZLL_Touclink_Target/707_Test_ZLL_Touclink_Target.h"; NULL_BTL; BOARD_HEADER="app\builder\707_Test_ZLL_Touclink_Target\707_Test_ZLL_Touclink_Target_board.h"; PLATFORM_HEADER="hal/micro/cortexm3/compiler/iar.h"; CORTEXM3; CORTEXM3_EMBER_MICRO; CORTEXM3_EM357; PHY_EM3XX; APPLICATION_TOKEN_HEADER="app/framework/util/tokens.h"; CONFIGURATION_HEADER="app/framework/util/config.h"; SENGLED_COR=1; ATTRIBUTE_STORAGE_CONFIGURATION="app/builder/707_Test_ZLL_Touclink_Target/707_Test_ZLL_Touclink_Target_endpoint_config.h"
  AARM.AUserIncludes: $FILE_DIR$\; ; ..\..\..\; ..\..\..\; ..\..\..\stack\; ..\..\..\hal\; ..\..\..\hal\..\
  OBJCOPY.OOCOutputFile: 707_Test_ZLL_Touclink_Target.s37
  postbuild: 707_Test_ZLL_Touclink_Target.bat $PROJ_DIR$ $TARGET_BPATH$
  ILINK.IlinkOutputFile: 707_Test_ZLL_Touclink_Target.out
  ILINK.IlinkConfigDefines: NULL_BTL=1
  ILINK.IlinkIcfFile: ../../../hal/micro/cortexm3/em35x/em357/iar-cfg.icf
  ILINK.IlinkProgramEntryLabel: halEntryPoint
  group (top)
    ./: 707_Test_ZLL_Touclink_Target_callbacks.c call-command-handler.c callback-stub.c cli.c stack-handler-stub.c
    ../../../hal/micro/cortexm3/: adc.c button.c buzzer.c cstartup-iar-common.c diagnostic.c faults.s79 isr-stubs.s79 led.c mfg-token.c micro-common.c micro.c mpu.c sleep.c token-def.c token.c uart.c
    ../../framework/util/: af-event.c af-main-common.c af-main-soc.c attribute-size.c attribute-storage.c attribute-table.c client-api.c message.c multi-network.c print-formatter.c print.c process-cluster-message.c process-global-message.c service-discovery-common.c service-discovery-soc.c util.c
    ../../framework/security/: af-node.c af-security-common.c af-trust-center.c crypto-state.c
    ../../../hal/micro/cortexm3/usb/cdc/: callbacks.c
    ../../util/serial/: command-interpreter2.c serial.c
    ../../framework/cli/: core-cli.c network-cli.c option-cli.c plugin-cli.c security-cli.c zcl-cli.c zdo-cli.c
    ../../../hal/micro/generic/: crc.c endian.c mem-util.c random.c sim-eeprom.c
    ../../../hal/micro/cortexm3/usb/: em_usbd.c em_usbdch9.c em_usbdep.c em_usbhal.c em_usbint.c
    ../../../hal/: ember-configuration.c
    ../../framework/plugin/end-device-support/: end-device-move.c end-device-support-cli.c end-device-support.c polling-common.c polling-soc.c
    ../../util/common/: form-and-join-node-adapter.c form-and-join.c library.c
    ../../../build/hal-library-cortexm3-iar-em357-em3xx/: hal-library.a
    ../../framework/plugin/interpan/: interpan-soc.c interpan.c
    ../../util/security/: security-address-cache.c
    ../../util/zigbee-framework/: zigbee-device-common.c zigbee-device-library.c
    ../../framework/plugin/zll-commissioning/: zll-commissioning-cli.c zll-commissioning-network.c zll-commissioning.c
    ../../framework/plugin/zll-utility-client/: zll-utility-client.c
    ../../framework/plugin/zll-utility-server/: zll-utility-server.c
  group Libraries
    ../../../build/alarm-stub-library-cortexm3-iar-em357-em3xx/: alarm-stub-library.a
    ../../../build/binding-table-library-cortexm3-iar-em357-em3xx/: binding-table-library.a
    ../../../build/cbke-163k1-stub-library-cortexm3-iar-em357-em3xx/: cbke-163k1-stub-library.a
    ../../../build/cbke-283k1-stub-library-cortexm3-iar-em357-em3xx/: cbke-283k1-stub-library.a
    ../../../build/cbke-library-dsa-sign-stub-cortexm3-iar-em357-em3xx/: cbke-library-dsa-sign-stub.a
    ../../../build/cbke-library-dsa-verify-stub-cortexm3-iar-em357-em3xx/: cbke-library-dsa-verify-stub.a
    ../../../build/cbke-stub-library-cortexm3-iar-em357-em3xx/: cbke-stub-library.a
    ../../../build/end-device-bind-stub-library-cortexm3-iar-em357-em3xx/: end-device-bind-stub-library.a
    ../../../build/install-code-library-stub-cortexm3-iar-em357-em3xx/: install-code-library-stub.a
    ../../../build/multi-network-stub-library-cortexm3-iar-em357-em3xx/: multi-network-stub-library.a
    ../../../build/packet-validate-library-cortexm3-iar-em357-em3xx-debug/: packet-validate-library.a
    ../../../build/rf4ce-stack-stub-library-cortexm3-iar-em357-em3xx/: rf4ce-stack-stub-library.a
    ../../../build/security-library-core-cortexm3-iar-em357-em3xx/: security-library-core.a
    ../../../build/security-library-link-keys-stub-cortexm3-iar-em357-em3xx/: security-library-link-keys-stub.a
    ../../../build/zigbee-pro-leaf-stack-cortexm3-iar-em357-em3xx-debug/: zigbee-pro-leaf-stack.a
    ../../../build/zll-library-cortexm3-iar-em357-em3xx-debug/: zll-library.a
