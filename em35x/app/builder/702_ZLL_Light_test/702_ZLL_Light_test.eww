<?xml version="1.0" encoding="iso-8859-1"?>
<!-- THIS IS A GENERATED FILE: PLEASE DO NOT EDIT -->

<workspace>
  <project>
    <path>$WS_DIR$\702_ZLL_Light_test.ewp</path>
  </project>
  <batchBuild/>
</workspace>
