<?xml version="1.0" encoding="iso-8859-1"?>
<!-- THIS IS A GENERATED FILE: PLEASE DO NOT EDIT -->

<workspace>
  <project>
    <path>$WS_DIR$\Z01_A19EUE27_Robin_OTA_TEST.ewp</path>
  </project>
  <batchBuild/>
</workspace>
