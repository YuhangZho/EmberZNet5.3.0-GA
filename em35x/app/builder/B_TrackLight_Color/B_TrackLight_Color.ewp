# IAR project B_TrackLight_Color.ewp, settings and files
configuration Normal (ARM, debug)
  General.OGChipSelectEditMenu: default None
  General.RTConfigPath2: $TOOLKIT_DIR$\INC\c\DLib_Config_Normal.h
  ICCARM.CCDefines: DEBUG; GENERATED_TOKEN_HEADER="app/builder/B_TrackLight_Color/B_TrackLight_Color_tokens.h"; ZA_GENERATED_HEADER="app/builder/B_TrackLight_Color/B_TrackLight_Color.h"; APP_BTL; BOARD_HEADER="app\builder\B_TrackLight_Color\B_TrackLight_Color_board.h"; PLATFORM_HEADER="hal/micro/cortexm3/compiler/iar.h"; CORTEXM3; CORTEXM3_EMBER_MICRO; CORTEXM3_EM357; PHY_EM3XX; APPLICATION_TOKEN_HEADER="app/framework/util/tokens.h"; CONFIGURATION_HEADER="app/framework/util/config.h"; E1K_CBA=0; E1K_CCA=1; E1K_CEA=2; E1L_CBA=3; E1L_CCA=4; E1L_CEA=5; MODEL_ID=E1K-CEA; SENGLED_Z01_A19_UART=1; ATTRIBUTE_STORAGE_CONFIGURATION="app/builder/B_TrackLight_Color/B_TrackLight_Color_endpoint_config.h"; __SOURCEFILE__="$FILE_FNAME$"
  ICCARM.CCDiagSuppress: Pa050
  ICCARM.CCIncludePath2: $FILE_DIR$\; ; ..\..\..\; ..\..\..\app\framework\include; ..\..\..\; ..\..\..\stack\; ..\..\..\hal\; ..\..\..\hal\..\
  ICCARM.CCOptLevel: 3
  ICCARM.CCOptStrategy: 1
  ICCARM.IccLang: 0
  AARM.ADefines: DEBUG; GENERATED_TOKEN_HEADER="app/builder/B_TrackLight_Color/B_TrackLight_Color_tokens.h"; ZA_GENERATED_HEADER="app/builder/B_TrackLight_Color/B_TrackLight_Color.h"; APP_BTL; BOARD_HEADER="app\builder\B_TrackLight_Color\B_TrackLight_Color_board.h"; PLATFORM_HEADER="hal/micro/cortexm3/compiler/iar.h"; CORTEXM3; CORTEXM3_EMBER_MICRO; CORTEXM3_EM357; PHY_EM3XX; APPLICATION_TOKEN_HEADER="app/framework/util/tokens.h"; CONFIGURATION_HEADER="app/framework/util/config.h"; E1K_CBA=0; E1K_CCA=1; E1K_CEA=2; E1L_CBA=3; E1L_CCA=4; E1L_CEA=5; MODEL_ID=E1K-CEA; SENGLED_Z01_A19_UART=1; ATTRIBUTE_STORAGE_CONFIGURATION="app/builder/B_TrackLight_Color/B_TrackLight_Color_endpoint_config.h"
  AARM.AUserIncludes: $FILE_DIR$\; ; ..\..\..\; ..\..\..\; ..\..\..\stack\; ..\..\..\hal\; ..\..\..\hal\..\
  OBJCOPY.OOCOutputFile: B_TrackLight_Color.s37
  postbuild: B_TrackLight_Color.bat $PROJ_DIR$ $TARGET_BPATH$
  ILINK.IlinkOutputFile: B_TrackLight_Color.out
  ILINK.IlinkConfigDefines: APP_BTL=1
  ILINK.IlinkIcfFile: ../../../hal/micro/cortexm3/em35x/em357/iar-cfg.icf
  ILINK.IlinkProgramEntryLabel: halEntryPoint
  group (top)
    ../../../hal/micro/cortexm3/: adc.c bootloader-interface-app.c bootloader-interface.c button.c buzzer.c cstartup-iar-common.c diagnostic.c faults.s79 isr-stubs.s79 led.c mfg-token.c micro-common.c micro.c mpu.c sleep.c token-def.c token.c uart.c
    ../../framework/plugin/address-table/: address-table-cli.c address-table-management.c address-table-soc.c
    ../../framework/util/: af-event.c af-main-common.c af-main-soc.c attribute-size.c attribute-storage.c attribute-table.c client-api.c message.c multi-network.c print-formatter.c print.c process-cluster-message.c process-global-message.c service-discovery-common.c service-discovery-soc.c util.c
    ../../framework/security/: af-node.c af-security-common.c af-trust-center.c crypto-state.c
    ./: B_TrackLight_Color_callbacks.c call-command-handler.c callback-stub.c cli.c stack-handler-stub.c
    ../../framework/plugin/basic/: basic.c
    ../../../hal/micro/cortexm3/usb/cdc/: callbacks.c
    ../../framework/plugin/color-control/: color-control.c
    ../../util/serial/: command-interpreter2.c serial.c
    ../../framework/cli/: core-cli.c network-cli.c option-cli.c plugin-cli.c security-cli.c zcl-cli.c zdo-cli.c
    ../../framework/plugin/counters/: counters-cli.c counters-ota.c counters-soc.c
    ../../../hal/micro/generic/: crc.c endian.c mem-util.c random.c sim-eeprom.c
    ../../framework/plugin/diagnostic-server/: diagnostic-server-soc.c
    ../../framework/plugin/eeprom/: eeprom-cli.c eeprom.c
    ../../../hal/micro/cortexm3/usb/: em_usbd.c em_usbdch9.c em_usbdep.c em_usbhal.c em_usbint.c
    ../../../hal/: ember-configuration.c
    ../../framework/plugin/ezmode-commissioning/: ez-mode.c
    ../../util/common/: form-and-join-node-adapter.c form-and-join.c library.c
    ../../framework/plugin/groups-server/: groups-server-cli.c groups-server.c
    ../../../build/hal-library-cortexm3-iar-em357-em3xx/: hal-library.a
    ../../framework/plugin/identify/: identify-cli.c identify.c
    ../../framework/plugin/idle-sleep/: idle-sleep-cli.c idle-sleep-soc.c idle-sleep.c
    ../../framework/plugin/level-control/: level-control.c
    ../../framework/plugin/network-find/: network-find.c
    ../../framework/plugin/on-off/: on-off.c
    ../../framework/plugin/ota-bootload/: ota-bootload-cli.c ota-bootload-soc.c
    ../../framework/plugin/ota-client/: ota-client-cli.c ota-client-page-request.c ota-client-signature-verify.c ota-client.c
    ../../framework/plugin/ota-client-policy/: ota-client-policy.c
    ../../framework/plugin/ota-common/: ota-common.c
    ../../framework/plugin/ota-storage-common/: ota-storage-common-cli.c ota-storage-common.c
    ../../framework/plugin/ota-storage-simple-eeprom/: ota-storage-eeprom-page-erase.c ota-storage-eeprom-read-modify-write.c ota-storage-eeprom.c
    ../../framework/plugin/ota-storage-simple/: ota-storage-simple-simulation.c ota-storage-simple.c
    ../../framework/plugin/reporting/: reporting-cli.c reporting.c
    ../../framework/plugin/scenes/: scenes-cli.c scenes.c
    ../../util/security/: security-address-cache.c
    ../../framework/plugin/sengled-ha-cli/: sengled-cli.c
    ../../framework/plugin/sengled-ha-common-TrackLight/: sengled-ha-common.c
    ../../framework/plugin/sengled-ha-ezmode/: sengled-ha-ezmode.c
    ../../framework/plugin/sengled-hardware-TrackLight/: sengled-hardware-TrackLight.c sengled-ledControl.c
    ../../framework/plugin/sengled-ha-network-TrackLight/: sengled-network.c
    ../../framework/plugin/simple-metering-server/: simple-metering-server-cli.c simple-metering-server.c simple-metering-test.c
    ../../util/zigbee-framework/: zigbee-device-common.c zigbee-device-library.c
  group Libraries
    ../../../build/alarm-stub-library-cortexm3-iar-em357-em3xx/: alarm-stub-library.a
    ../../../build/binding-table-library-cortexm3-iar-em357-em3xx/: binding-table-library.a
    ../../../build/cbke-163k1-stub-library-cortexm3-iar-em357-em3xx/: cbke-163k1-stub-library.a
    ../../../build/cbke-283k1-stub-library-cortexm3-iar-em357-em3xx/: cbke-283k1-stub-library.a
    ../../../build/cbke-library-dsa-sign-stub-cortexm3-iar-em357-em3xx/: cbke-library-dsa-sign-stub.a
    ../../../build/cbke-library-dsa-verify-stub-cortexm3-iar-em357-em3xx/: cbke-library-dsa-verify-stub.a
    ../../../build/cbke-stub-library-cortexm3-iar-em357-em3xx/: cbke-stub-library.a
    ../../../build/end-device-bind-stub-library-cortexm3-iar-em357-em3xx/: end-device-bind-stub-library.a
    ../../../build/install-code-library-stub-cortexm3-iar-em357-em3xx/: install-code-library-stub.a
    ../../../build/multi-network-stub-library-cortexm3-iar-em357-em3xx/: multi-network-stub-library.a
    ../../../build/packet-validate-library-cortexm3-iar-em357-em3xx-debug/: packet-validate-library.a
    ../../../build/rf4ce-stack-stub-library-cortexm3-iar-em357-em3xx/: rf4ce-stack-stub-library.a
    ../../../build/security-library-core-cortexm3-iar-em357-em3xx/: security-library-core.a
    ../../../build/security-library-link-keys-cortexm3-iar-em357-em3xx/: security-library-link-keys.a
    ../../../build/zigbee-pro-stack-cortexm3-iar-em357-em3xx-debug/: zigbee-pro-stack.a
    ../../../build/zll-stub-library-cortexm3-iar-em357-em3xx/: zll-stub-library.a
