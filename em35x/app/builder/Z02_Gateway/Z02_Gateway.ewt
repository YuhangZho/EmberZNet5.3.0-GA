<?xml version="1.0" encoding="iso-8859-1"?>

<project>
  <fileVersion>2</fileVersion>
  <configuration>
    <name>Normal</name>
    <toolchain>
      <name>ARM</name>
    </toolchain>
    <debug>1</debug>
    <settings>
      <name>RuntimeChecking</name>
      <archiveVersion>0</archiveVersion>
      <data>
        <version>2</version>
        <wantNonLocal>1</wantNonLocal>
        <debug>1</debug>
        <option>
          <name>GenRtcDebugHeap</name>
          <state>0</state>
        </option>
        <option>
          <name>GenRtcEnableBoundsChecking</name>
          <state>0</state>
        </option>
        <option>
          <name>GenRtcCheckPtrsNonInstrMem</name>
          <state>1</state>
        </option>
        <option>
          <name>GenRtcTrackPointerBounds</name>
          <state>1</state>
        </option>
        <option>
          <name>GenRtcCheckAccesses</name>
          <state>1</state>
        </option>
        <option>
          <name>GenRtcGenerateEntries</name>
          <state>0</state>
        </option>
        <option>
          <name>GenRtcNrTrackedPointers</name>
          <state>1000</state>
        </option>
        <option>
          <name>GenRtcIntOverflow</name>
          <state>0</state>
        </option>
        <option>
          <name>GenRtcIncUnsigned</name>
          <state>0</state>
        </option>
        <option>
          <name>GenRtcIntConversion</name>
          <state>0</state>
        </option>
        <option>
          <name>GenRtcInclExplicit</name>
          <state>0</state>
        </option>
        <option>
          <name>GenRtcIntShiftOverflow</name>
          <state>0</state>
        </option>
        <option>
          <name>GenRtcInclUnsignedShiftOverflow</name>
          <state>0</state>
        </option>
        <option>
          <name>GenRtcUnhandledCase</name>
          <state>0</state>
        </option>
        <option>
          <name>GenRtcDivByZero</name>
          <state>0</state>
        </option>
        <option>
          <name>GenRtcEnable</name>
          <state>0</state>
        </option>
        <option>
          <name>GenRtcCheckPtrsNonInstrFunc</name>
          <state>1</state>
        </option>
      </data>
    </settings>
  </configuration>
  <group>
    <name>Libraries</name>
    <file>
      <name>$PROJ_DIR$\..\..\..\build\alarm-stub-library-cortexm3-iar-em357-em3xx\alarm-stub-library.a</name>
    </file>
    <file>
      <name>$PROJ_DIR$\..\..\..\build\binding-table-library-cortexm3-iar-em357-em3xx\binding-table-library.a</name>
    </file>
    <file>
      <name>$PROJ_DIR$\..\..\..\build\cbke-163k1-stub-library-cortexm3-iar-em357-em3xx\cbke-163k1-stub-library.a</name>
    </file>
    <file>
      <name>$PROJ_DIR$\..\..\..\build\cbke-283k1-stub-library-cortexm3-iar-em357-em3xx\cbke-283k1-stub-library.a</name>
    </file>
    <file>
      <name>$PROJ_DIR$\..\..\..\build\cbke-library-dsa-sign-stub-cortexm3-iar-em357-em3xx\cbke-library-dsa-sign-stub.a</name>
    </file>
    <file>
      <name>$PROJ_DIR$\..\..\..\build\cbke-library-dsa-verify-stub-cortexm3-iar-em357-em3xx\cbke-library-dsa-verify-stub.a</name>
    </file>
    <file>
      <name>$PROJ_DIR$\..\..\..\build\cbke-stub-library-cortexm3-iar-em357-em3xx\cbke-stub-library.a</name>
    </file>
    <file>
      <name>$PROJ_DIR$\..\..\..\build\end-device-bind-library-cortexm3-iar-em357-em3xx\end-device-bind-library.a</name>
    </file>
    <file>
      <name>$PROJ_DIR$\..\..\..\build\install-code-library-stub-cortexm3-iar-em357-em3xx\install-code-library-stub.a</name>
    </file>
    <file>
      <name>$PROJ_DIR$\..\..\..\build\multi-network-stub-library-cortexm3-iar-em357-em3xx\multi-network-stub-library.a</name>
    </file>
    <file>
      <name>$PROJ_DIR$\..\..\..\build\packet-validate-library-cortexm3-iar-em357-em3xx\packet-validate-library.a</name>
    </file>
    <file>
      <name>$PROJ_DIR$\..\..\..\build\rf4ce-stack-stub-library-cortexm3-iar-em357-em3xx\rf4ce-stack-stub-library.a</name>
    </file>
    <file>
      <name>$PROJ_DIR$\..\..\..\build\security-library-core-cortexm3-iar-em357-em3xx\security-library-core.a</name>
    </file>
    <file>
      <name>$PROJ_DIR$\..\..\..\build\security-library-link-keys-stub-cortexm3-iar-em357-em3xx\security-library-link-keys-stub.a</name>
    </file>
    <file>
      <name>$PROJ_DIR$\..\..\..\build\zigbee-pro-stack-cortexm3-iar-em357-em3xx\zigbee-pro-stack.a</name>
    </file>
    <file>
      <name>$PROJ_DIR$\..\..\..\build\zll-stub-library-cortexm3-iar-em357-em3xx\zll-stub-library.a</name>
    </file>
  </group>
  <file>
    <name>$PROJ_DIR$\..\..\..\hal\micro\cortexm3\adc.c</name>
  </file>
  <file>
    <name>$PROJ_DIR$\..\..\framework\plugin\address-table\address-table-cli.c</name>
  </file>
  <file>
    <name>$PROJ_DIR$\..\..\framework\plugin\address-table\address-table-management.c</name>
  </file>
  <file>
    <name>$PROJ_DIR$\..\..\framework\plugin\address-table\address-table-soc.c</name>
  </file>
  <file>
    <name>$PROJ_DIR$\..\..\framework\util\af-event.c</name>
  </file>
  <file>
    <name>$PROJ_DIR$\..\..\framework\util\af-main-common.c</name>
  </file>
  <file>
    <name>$PROJ_DIR$\..\..\framework\util\af-main-soc.c</name>
  </file>
  <file>
    <name>$PROJ_DIR$\..\..\framework\security\af-node.c</name>
  </file>
  <file>
    <name>$PROJ_DIR$\..\..\framework\security\af-security-common.c</name>
  </file>
  <file>
    <name>$PROJ_DIR$\..\..\framework\security\af-trust-center.c</name>
  </file>
  <file>
    <name>$PROJ_DIR$\..\..\framework\util\attribute-size.c</name>
  </file>
  <file>
    <name>$PROJ_DIR$\..\..\framework\util\attribute-storage.c</name>
  </file>
  <file>
    <name>$PROJ_DIR$\..\..\framework\util\attribute-table.c</name>
  </file>
  <file>
    <name>$PROJ_DIR$\..\..\..\hal\micro\cortexm3\bootloader-interface-app.c</name>
  </file>
  <file>
    <name>$PROJ_DIR$\..\..\..\hal\micro\cortexm3\bootloader-interface.c</name>
  </file>
  <file>
    <name>$PROJ_DIR$\..\..\..\hal\micro\cortexm3\button.c</name>
  </file>
  <file>
    <name>$PROJ_DIR$\..\..\..\hal\micro\cortexm3\buzzer.c</name>
  </file>
  <file>
    <name>$PROJ_DIR$\call-command-handler.c</name>
  </file>
  <file>
    <name>$PROJ_DIR$\callback-stub.c</name>
  </file>
  <file>
    <name>$PROJ_DIR$\..\..\..\hal\micro\cortexm3\usb\cdc\callbacks.c</name>
  </file>
  <file>
    <name>$PROJ_DIR$\cli.c</name>
  </file>
  <file>
    <name>$PROJ_DIR$\..\..\framework\util\client-api.c</name>
  </file>
  <file>
    <name>$PROJ_DIR$\..\..\util\serial\command-interpreter2.c</name>
  </file>
  <file>
    <name>$PROJ_DIR$\..\..\framework\plugin\concentrator\concentrator-support-cli.c</name>
  </file>
  <file>
    <name>$PROJ_DIR$\..\..\framework\plugin\concentrator\concentrator-support.c</name>
  </file>
  <file>
    <name>$PROJ_DIR$\..\..\framework\cli\core-cli.c</name>
  </file>
  <file>
    <name>$PROJ_DIR$\..\..\framework\plugin\counters\counters-cli.c</name>
  </file>
  <file>
    <name>$PROJ_DIR$\..\..\framework\plugin\counters\counters-ota.c</name>
  </file>
  <file>
    <name>$PROJ_DIR$\..\..\framework\plugin\counters\counters-soc.c</name>
  </file>
  <file>
    <name>$PROJ_DIR$\..\..\..\hal\micro\generic\crc.c</name>
  </file>
  <file>
    <name>$PROJ_DIR$\..\..\framework\security\crypto-state.c</name>
  </file>
  <file>
    <name>$PROJ_DIR$\..\..\..\hal\micro\cortexm3\cstartup-iar-common.c</name>
  </file>
  <file>
    <name>$PROJ_DIR$\..\..\..\hal\micro\cortexm3\diagnostic.c</name>
  </file>
  <file>
    <name>$PROJ_DIR$\..\..\framework\plugin\eeprom\eeprom-cli.c</name>
  </file>
  <file>
    <name>$PROJ_DIR$\..\..\framework\plugin\eeprom\eeprom.c</name>
  </file>
  <file>
    <name>$PROJ_DIR$\..\..\..\hal\micro\cortexm3\usb\em_usbd.c</name>
  </file>
  <file>
    <name>$PROJ_DIR$\..\..\..\hal\micro\cortexm3\usb\em_usbdch9.c</name>
  </file>
  <file>
    <name>$PROJ_DIR$\..\..\..\hal\micro\cortexm3\usb\em_usbdep.c</name>
  </file>
  <file>
    <name>$PROJ_DIR$\..\..\..\hal\micro\cortexm3\usb\em_usbhal.c</name>
  </file>
  <file>
    <name>$PROJ_DIR$\..\..\..\hal\micro\cortexm3\usb\em_usbint.c</name>
  </file>
  <file>
    <name>$PROJ_DIR$\..\..\..\hal\ember-configuration.c</name>
  </file>
  <file>
    <name>$PROJ_DIR$\..\..\..\hal\micro\generic\endian.c</name>
  </file>
  <file>
    <name>$PROJ_DIR$\..\..\..\hal\micro\cortexm3\faults.s79</name>
  </file>
  <file>
    <name>$PROJ_DIR$\..\..\util\common\form-and-join-node-adapter.c</name>
  </file>
  <file>
    <name>$PROJ_DIR$\..\..\util\common\form-and-join.c</name>
  </file>
  <file>
    <name>$PROJ_DIR$\..\..\..\build\hal-library-cortexm3-iar-em357-em3xx\hal-library.a</name>
  </file>
  <file>
    <name>$PROJ_DIR$\..\..\framework\plugin\identify\identify-cli.c</name>
  </file>
  <file>
    <name>$PROJ_DIR$\..\..\framework\plugin\identify-feedback\identify-feedback.c</name>
  </file>
  <file>
    <name>$PROJ_DIR$\..\..\framework\plugin\identify\identify.c</name>
  </file>
  <file>
    <name>$PROJ_DIR$\..\..\framework\plugin\idle-sleep\idle-sleep-cli.c</name>
  </file>
  <file>
    <name>$PROJ_DIR$\..\..\framework\plugin\idle-sleep\idle-sleep-soc.c</name>
  </file>
  <file>
    <name>$PROJ_DIR$\..\..\framework\plugin\idle-sleep\idle-sleep.c</name>
  </file>
  <file>
    <name>$PROJ_DIR$\..\..\..\hal\micro\cortexm3\isr-stubs.s79</name>
  </file>
  <file>
    <name>$PROJ_DIR$\..\..\..\hal\micro\cortexm3\led.c</name>
  </file>
  <file>
    <name>$PROJ_DIR$\..\..\util\common\library.c</name>
  </file>
  <file>
    <name>$PROJ_DIR$\..\..\..\hal\micro\generic\mem-util.c</name>
  </file>
  <file>
    <name>$PROJ_DIR$\..\..\framework\util\message.c</name>
  </file>
  <file>
    <name>$PROJ_DIR$\..\..\..\hal\micro\cortexm3\mfg-token.c</name>
  </file>
  <file>
    <name>$PROJ_DIR$\..\..\..\hal\micro\cortexm3\micro-common.c</name>
  </file>
  <file>
    <name>$PROJ_DIR$\..\..\..\hal\micro\cortexm3\micro.c</name>
  </file>
  <file>
    <name>$PROJ_DIR$\..\..\..\hal\micro\cortexm3\mpu.c</name>
  </file>
  <file>
    <name>$PROJ_DIR$\..\..\framework\util\multi-network.c</name>
  </file>
  <file>
    <name>$PROJ_DIR$\..\..\framework\cli\network-cli.c</name>
  </file>
  <file>
    <name>$PROJ_DIR$\..\..\framework\plugin\network-find\network-find.c</name>
  </file>
  <file>
    <name>$PROJ_DIR$\..\..\framework\cli\option-cli.c</name>
  </file>
  <file>
    <name>$PROJ_DIR$\..\..\framework\plugin\ota-common\ota-common.c</name>
  </file>
  <file>
    <name>$PROJ_DIR$\..\..\framework\plugin\ota-server\ota-server-cli.c</name>
  </file>
  <file>
    <name>$PROJ_DIR$\..\..\framework\plugin\ota-server\ota-server-page-request.c</name>
  </file>
  <file>
    <name>$PROJ_DIR$\..\..\framework\plugin\ota-server-policy\ota-server-policy.c</name>
  </file>
  <file>
    <name>$PROJ_DIR$\..\..\framework\plugin\ota-server\ota-server.c</name>
  </file>
  <file>
    <name>$PROJ_DIR$\..\..\framework\plugin\ota-storage-common\ota-storage-common-cli.c</name>
  </file>
  <file>
    <name>$PROJ_DIR$\..\..\framework\plugin\ota-storage-common\ota-storage-common.c</name>
  </file>
  <file>
    <name>$PROJ_DIR$\..\..\framework\plugin\ota-storage-simple-eeprom\ota-storage-eeprom-page-erase.c</name>
  </file>
  <file>
    <name>$PROJ_DIR$\..\..\framework\plugin\ota-storage-simple-eeprom\ota-storage-eeprom-read-modify-write.c</name>
  </file>
  <file>
    <name>$PROJ_DIR$\..\..\framework\plugin\ota-storage-simple-eeprom\ota-storage-eeprom.c</name>
  </file>
  <file>
    <name>$PROJ_DIR$\..\..\framework\plugin\ota-storage-simple\ota-storage-simple-simulation.c</name>
  </file>
  <file>
    <name>$PROJ_DIR$\..\..\framework\plugin\ota-storage-simple\ota-storage-simple.c</name>
  </file>
  <file>
    <name>$PROJ_DIR$\..\..\framework\cli\plugin-cli.c</name>
  </file>
  <file>
    <name>$PROJ_DIR$\..\..\framework\util\print-formatter.c</name>
  </file>
  <file>
    <name>$PROJ_DIR$\..\..\framework\util\print.c</name>
  </file>
  <file>
    <name>$PROJ_DIR$\..\..\framework\util\process-cluster-message.c</name>
  </file>
  <file>
    <name>$PROJ_DIR$\..\..\framework\util\process-global-message.c</name>
  </file>
  <file>
    <name>$PROJ_DIR$\..\..\..\hal\micro\generic\random.c</name>
  </file>
  <file>
    <name>$PROJ_DIR$\..\..\util\security\security-address-cache.c</name>
  </file>
  <file>
    <name>$PROJ_DIR$\..\..\framework\cli\security-cli.c</name>
  </file>
  <file>
    <name>$PROJ_DIR$\..\..\util\serial\serial.c</name>
  </file>
  <file>
    <name>$PROJ_DIR$\..\..\framework\plugin\z02-gateway-app\SerialPortProtocol.c</name>
  </file>
  <file>
    <name>$PROJ_DIR$\..\..\framework\util\service-discovery-common.c</name>
  </file>
  <file>
    <name>$PROJ_DIR$\..\..\framework\util\service-discovery-soc.c</name>
  </file>
  <file>
    <name>$PROJ_DIR$\..\..\..\hal\micro\generic\sim-eeprom.c</name>
  </file>
  <file>
    <name>$PROJ_DIR$\..\..\framework\plugin\simple-metering-client\simple-metering-client.c</name>
  </file>
  <file>
    <name>$PROJ_DIR$\..\..\..\hal\micro\cortexm3\sleep.c</name>
  </file>
  <file>
    <name>$PROJ_DIR$\..\..\util\source-route-common.c</name>
  </file>
  <file>
    <name>$PROJ_DIR$\..\..\util\source-route.c</name>
  </file>
  <file>
    <name>$PROJ_DIR$\stack-handler-stub.c</name>
  </file>
  <file>
    <name>$PROJ_DIR$\..\..\..\hal\micro\cortexm3\token-def.c</name>
  </file>
  <file>
    <name>$PROJ_DIR$\..\..\..\hal\micro\cortexm3\token.c</name>
  </file>
  <file>
    <name>$PROJ_DIR$\..\..\framework\plugin\z02-gateway-app\trust-center-join-decision.c</name>
  </file>
  <file>
    <name>$PROJ_DIR$\..\..\..\hal\micro\cortexm3\uart.c</name>
  </file>
  <file>
    <name>$PROJ_DIR$\..\..\framework\util\util.c</name>
  </file>
  <file>
    <name>$PROJ_DIR$\..\..\framework\plugin\z02-gateway-app\Z02_Gateway_App.c</name>
  </file>
  <file>
    <name>$PROJ_DIR$\Z02_Gateway_callbacks.c</name>
  </file>
  <file>
    <name>$PROJ_DIR$\..\..\framework\cli\zcl-cli.c</name>
  </file>
  <file>
    <name>$PROJ_DIR$\..\..\framework\cli\zdo-cli.c</name>
  </file>
  <file>
    <name>$PROJ_DIR$\..\..\util\zigbee-framework\zigbee-device-common.c</name>
  </file>
  <file>
    <name>$PROJ_DIR$\..\..\util\zigbee-framework\zigbee-device-library.c</name>
  </file>
</project>


