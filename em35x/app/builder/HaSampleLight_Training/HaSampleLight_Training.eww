<?xml version="1.0" encoding="iso-8859-1"?>
<!-- THIS IS A GENERATED FILE: PLEASE DO NOT EDIT -->

<workspace>
  <project>
    <path>$WS_DIR$\HaSampleLight_Training.ewp</path>
  </project>
  <batchBuild/>
</workspace>
