# IAR project Z02_Gateway_rainbow.ewp, settings and files
configuration Normal (ARM, debug)
  General.OGChipSelectEditMenu: default None
  General.RTConfigPath2: $TOOLKIT_DIR$\INC\c\DLib_Config_Normal.h
  ICCARM.CCDefines: GENERATED_TOKEN_HEADER="app/builder/Z02_Gateway_rainbow/Z02_Gateway_rainbow_tokens.h"; ZA_GENERATED_HEADER="app/builder/Z02_Gateway_rainbow/Z02_Gateway_rainbow.h"; APP_BTL; BOARD_HEADER="app\builder\Z02_Gateway_rainbow\Z02_Gateway_rainbow_board.h"; PLATFORM_HEADER="hal/micro/cortexm3/compiler/iar.h"; CORTEXM3; CORTEXM3_EMBER_MICRO; CORTEXM3_EM357; PHY_EM3XX; APPLICATION_TOKEN_HEADER="app/framework/util/tokens.h"; CONFIGURATION_HEADER="app/framework/util/config.h"; EMBER_APPLICATION_RECEIVES_SUPPORTED_ZDO_REQUESTS=1; ATTRIBUTE_STORAGE_CONFIGURATION="app/builder/Z02_Gateway_rainbow/Z02_Gateway_rainbow_endpoint_config.h"; __SOURCEFILE__="$FILE_FNAME$"
  ICCARM.CCDiagSuppress: Pa050
  ICCARM.CCIncludePath2: $FILE_DIR$\; ; ..\..\..\; ..\..\..\app\framework\include; ..\..\..\; ..\..\..\stack\; ..\..\..\hal\; ..\..\..\hal\..\
  ICCARM.CCOptLevel: 3
  ICCARM.CCOptStrategy: 1
  ICCARM.IccLang: 0
  AARM.ADefines: GENERATED_TOKEN_HEADER="app/builder/Z02_Gateway_rainbow/Z02_Gateway_rainbow_tokens.h"; ZA_GENERATED_HEADER="app/builder/Z02_Gateway_rainbow/Z02_Gateway_rainbow.h"; APP_BTL; BOARD_HEADER="app\builder\Z02_Gateway_rainbow\Z02_Gateway_rainbow_board.h"; PLATFORM_HEADER="hal/micro/cortexm3/compiler/iar.h"; CORTEXM3; CORTEXM3_EMBER_MICRO; CORTEXM3_EM357; PHY_EM3XX; APPLICATION_TOKEN_HEADER="app/framework/util/tokens.h"; CONFIGURATION_HEADER="app/framework/util/config.h"; EMBER_APPLICATION_RECEIVES_SUPPORTED_ZDO_REQUESTS=1; ATTRIBUTE_STORAGE_CONFIGURATION="app/builder/Z02_Gateway_rainbow/Z02_Gateway_rainbow_endpoint_config.h"
  AARM.AUserIncludes: $FILE_DIR$\; ; ..\..\..\; ..\..\..\; ..\..\..\stack\; ..\..\..\hal\; ..\..\..\hal\..\
  OBJCOPY.OOCOutputFile: Z02_Gateway_rainbow.s37
  postbuild: Z02_Gateway_rainbow.bat $PROJ_DIR$ $TARGET_BPATH$
  ILINK.IlinkOutputFile: Z02_Gateway_rainbow.out
  ILINK.IlinkConfigDefines: APP_BTL=1
  ILINK.IlinkIcfFile: ../../../hal/micro/cortexm3/em35x/em357/iar-cfg.icf
  ILINK.IlinkProgramEntryLabel: halEntryPoint
  group (top)
    ../../../hal/micro/cortexm3/: adc.c bootloader-interface-app.c bootloader-interface.c button.c buzzer.c cstartup-iar-common.c diagnostic.c faults.s79 isr-stubs.s79 led.c mfg-token.c micro-common.c micro.c mpu.c sleep.c token-def.c token.c uart.c
    ../../framework/plugin/address-table/: address-table-cli.c address-table-management.c address-table-soc.c
    ../../framework/util/: af-event.c af-main-common.c af-main-soc.c attribute-size.c attribute-storage.c attribute-table.c client-api.c message.c multi-network.c print-formatter.c print.c process-cluster-message.c process-global-message.c service-discovery-common.c service-discovery-soc.c util.c
    ../../framework/security/: af-node.c af-security-common.c af-trust-center.c crypto-state.c
    ./: call-command-handler.c callback-stub.c cli.c stack-handler-stub.c Z02_Gateway_rainbow_callbacks.c
    ../../../hal/micro/cortexm3/usb/cdc/: callbacks.c
    ../../util/serial/: command-interpreter2.c serial.c
    ../../framework/plugin/concentrator/: concentrator-support-cli.c concentrator-support.c
    ../../framework/cli/: core-cli.c network-cli.c option-cli.c plugin-cli.c security-cli.c zcl-cli.c zdo-cli.c
    ../../framework/plugin/counters/: counters-cli.c counters-ota.c counters-soc.c
    ../../../hal/micro/generic/: crc.c endian.c mem-util.c random.c sim-eeprom.c
    ../../framework/plugin/eeprom/: eeprom-cli.c eeprom.c
    ../../../hal/micro/cortexm3/usb/: em_usbd.c em_usbdch9.c em_usbdep.c em_usbhal.c em_usbint.c
    ../../../hal/: ember-configuration.c
    ../../util/common/: form-and-join-node-adapter.c form-and-join.c library.c
    ../../../build/hal-library-cortexm3-iar-em357-em3xx/: hal-library.a
    ../../framework/plugin/ias-zone-client/: ias-zone-client-cli.c ias-zone-client.c
    ../../framework/plugin/identify/: identify-cli.c identify.c
    ../../framework/plugin/identify-feedback/: identify-feedback.c
    ../../framework/plugin/idle-sleep/: idle-sleep-cli.c idle-sleep-soc.c idle-sleep.c
    ../../framework/plugin/network-find/: network-find.c
    ../../framework/plugin/ota-common/: ota-common.c
    ../../framework/plugin/ota-server/: ota-server-cli.c ota-server-page-request.c ota-server.c
    ../../framework/plugin/ota-server-policy/: ota-server-policy.c
    ../../framework/plugin/ota-storage-common/: ota-storage-common-cli.c ota-storage-common.c
    ../../framework/plugin/ota-storage-simple-eeprom/: ota-storage-eeprom-page-erase.c ota-storage-eeprom-read-modify-write.c ota-storage-eeprom.c
    ../../framework/plugin/ota-storage-simple/: ota-storage-simple-simulation.c ota-storage-simple.c
    ../../util/security/: security-address-cache.c
    ../../framework/plugin/z02-gateway-app/: SerialPortProtocol.c trust-center-join-decision.c Z02_Gateway_App.c
    ../../framework/plugin/simple-metering-client/: simple-metering-client.c
    ../../util/: source-route-common.c source-route.c
    ../../util/zigbee-framework/: zigbee-device-common.c zigbee-device-library.c
  group Libraries
    ../../../build/alarm-stub-library-cortexm3-iar-em357-em3xx/: alarm-stub-library.a
    ../../../build/binding-table-library-cortexm3-iar-em357-em3xx/: binding-table-library.a
    ../../../build/cbke-163k1-stub-library-cortexm3-iar-em357-em3xx/: cbke-163k1-stub-library.a
    ../../../build/cbke-283k1-stub-library-cortexm3-iar-em357-em3xx/: cbke-283k1-stub-library.a
    ../../../build/cbke-library-dsa-sign-stub-cortexm3-iar-em357-em3xx/: cbke-library-dsa-sign-stub.a
    ../../../build/cbke-library-dsa-verify-stub-cortexm3-iar-em357-em3xx/: cbke-library-dsa-verify-stub.a
    ../../../build/cbke-stub-library-cortexm3-iar-em357-em3xx/: cbke-stub-library.a
    ../../../build/end-device-bind-library-cortexm3-iar-em357-em3xx/: end-device-bind-library.a
    ../../../build/install-code-library-stub-cortexm3-iar-em357-em3xx/: install-code-library-stub.a
    ../../../build/multi-network-stub-library-cortexm3-iar-em357-em3xx/: multi-network-stub-library.a
    ../../../build/packet-validate-library-cortexm3-iar-em357-em3xx/: packet-validate-library.a
    ../../../build/rf4ce-stack-stub-library-cortexm3-iar-em357-em3xx/: rf4ce-stack-stub-library.a
    ../../../build/security-library-core-cortexm3-iar-em357-em3xx/: security-library-core.a
    ../../../build/security-library-link-keys-stub-cortexm3-iar-em357-em3xx/: security-library-link-keys-stub.a
    ../../../build/zigbee-pro-stack-cortexm3-iar-em357-em3xx/: zigbee-pro-stack.a
    ../../../build/zll-stub-library-cortexm3-iar-em357-em3xx/: zll-stub-library.a
